# IAR project Pump.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S903K3 STM8S903K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S903
  ICCSTM8.CCIncludePath2: ..\LIB\inc; ..\LIB\src; ..\LIB; ..\USER; ..\BSP\CLOCK; ..\BSP\MOTOR; ..\BSP\TIMER; ..\BSP\BEMF; ..\BSP; ..\BSP\CAPTURE; ..\BSP\POWER; ..\BSP\USART
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Pump.hex
  ILINK.IlinkOutputFile: Pump.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s903k3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group BSP
    ../BSP/BEMF/: bemf.c
    ../BSP/CAPTURE/: capture.c
    ../BSP/CLOCK/: clock.c
    ../BSP/MOTOR/: motor.c
    ../BSP/POWER/: power.c power.c
    ../BSP/TIMER/: timer.c
    ../BSP/USART/: usart.c
  group LIB
    ../LIB/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_itc.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_wwdg.c
  group USER
    ../USER/: confer.h control.c main.c pid.c stm8s_conf.h stm8s_it.c
